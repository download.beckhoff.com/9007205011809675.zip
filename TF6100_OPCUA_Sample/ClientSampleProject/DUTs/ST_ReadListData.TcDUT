{attribute 'pack_mode' := '1'}
TYPE ST_ReadListData :
STRUCT
	stReadListReturnInfo	: ARRAY [1..2] OF ST_UAReadListReturnInfo;
	nIntVar1				: INT; 
	nIntVar2				: INT; 
END_STRUCT
END_TYPE
